options:
  parameters:
    author: Paul Maine
    generate_options: qt_gui
    id: MonoFmReceiver
    output_language: python
    realtime_scheduling: '1'
    title: RTL-SDR Mono FM Receiver
  states: {}

blocks:
- name: rf_gain
  id: variable_qtgui_range
  parameters:
    gui_hint: 3,0,1,3
    label: RF Gain
    start: '0'
    step: '1'
    stop: '70'
    value: '50'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 2.048e6
  states: {}
- name: sq_level
  id: variable_qtgui_range
  parameters:
    gui_hint: 4,0,1,3
    label: Squelch
    rangeType: int
    start: '-100'
    step: '5'
    stop: '0'
    value: '-50'
  states: {}
- name: tuner
  id: variable_qtgui_range
  parameters:
    gui_hint: 1,0,1,3
    label: Tuner
    start: 87.9e6
    step: 100e3
    stop: 108.1e6
    value: 99.1e6
  states: {}
- name: variable_0
  id: variable
  parameters:
    value: '0'
  states: {}
- name: volume
  id: variable_qtgui_range
  parameters:
    gui_hint: 2,0,1,3
    label: Volume
    start: '0'
    step: '50e-3'
    stop: '1'
    value: '300e-3'
  states: {}
- name: analog_fm_demod_cf_0
  id: analog_fm_demod_cf
  parameters:
    audio_decim: '4'
    audio_pass: '16000'
    audio_stop: '20000'
    chan_rate: 192e3
    deviation: '75000'
    gain: '1.0'
    tau: '75e-6'
  states: {}
- name: analog_simple_squelch_cc_0
  id: analog_simple_squelch_cc
  parameters:
    alpha: '1'
    threshold: sq_level
  states: {}
- name: audio_sink_0
  id: audio_sink
  parameters:
    samp_rate: '48000'
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: volume
    type: float
  states: {}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    cutoff_freq: 75e3
    decim: '1'
    gain: '1'
    samp_rate: samp_rate
    type: fir_filter_ccf
    width: 25e3
    win: window.WIN_HAMMING
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: tuner
    fftsize: '1024'
    gui_hint: 5,3,1,3
    name: Spectrum Analyzer Output of SDR
    type: complex
    ymax: '5'
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    gui_hint: 5,0,1,3
    name: Oscilloscope Output of SDR
    size: '1024'
    srate: samp_rate
    type: complex
  states: {}
- name: qtgui_waterfall_sink_x_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate
    fc: tuner
    fftsize: '1024'
    gui_hint: 0,0,1,6
    name: 2 MHz Bandwidth Waterfall
    type: complex
  states: {}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    decim: '32'
    interp: '3'
    type: ccc
  states: {}
- name: rtlsdr_source_0
  id: rtlsdr_source
  parameters:
    bb_gain0: '20'
    bw0: 200e3
    freq0: tuner
    gain0: '50'
    gain_mode0: 'False'
    if_gain0: '20'
    sample_rate: samp_rate
    sync: sync
    type: fc32
  states: {}

connections:
- [analog_fm_demod_cf_0, '0', blocks_multiply_const_vxx_0, '0']
- [analog_simple_squelch_cc_0, '0', analog_fm_demod_cf_0, '0']
- [blocks_multiply_const_vxx_0, '0', audio_sink_0, '0']
- [low_pass_filter_0, '0', rational_resampler_xxx_0, '0']
- [rational_resampler_xxx_0, '0', analog_simple_squelch_cc_0, '0']
- [rtlsdr_source_0, '0', low_pass_filter_0, '0']
- [rtlsdr_source_0, '0', qtgui_freq_sink_x_0, '0']
- [rtlsdr_source_0, '0', qtgui_time_sink_x_0, '0']
- [rtlsdr_source_0, '0', qtgui_waterfall_sink_x_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
