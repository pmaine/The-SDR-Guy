options:
  parameters:
    author: Paul Maine
    generate_options: qt_gui
    id: FM_Stereo_Receiver
    output_language: python
    title: RTL-SDR FM Stereo Reciever
  states: {}

blocks:
- name: freq
  id: variable
  parameters:
    value: '0'
  states: {}
- name: rf_gain
  id: variable_qtgui_range
  parameters:
    gui_hint: 3,0,1,3
    label: RF Gain
    rangeType: int
    start: '0'
    step: '1'
    stop: '70'
    value: '50'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 2.048e6
  states: {}
- name: sq_level
  id: variable_qtgui_range
  parameters:
    gui_hint: 4,0,1,3
    label: Squelch
    start: '-100'
    step: '5'
    stop: '0'
    value: '-50'
  states: {}
- name: tuner
  id: variable_qtgui_range
  parameters:
    gui_hint: 1,0,1,3
    label: Tuner
    start: 87.9e6
    step: 200e3
    stop: 108.1e6
    value: 100.3e6
  states: {}
- name: volume
  id: variable_qtgui_range
  parameters:
    gui_hint: 2,0,1,3
    label: Volume
    start: '0'
    step: '50e-3'
    stop: '1'
    value: '300e-3'
  states: {}
- name: analog_simple_squelch_cc_0
  id: analog_simple_squelch_cc
  parameters:
    alpha: '1'
    threshold: sq_level
  states: {}
- name: analog_wfm_rcv_pll_0
  id: analog_wfm_rcv_pll
  parameters:
    audio_decimation: '4'
    deemph_tau: '75e-6'
    quad_rate: 192e3
  states: {}
- name: audio_sink_0
  id: audio_sink
  parameters:
    num_inputs: '2'
    samp_rate: '48000'
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: volume
    type: float
  states: {}
- name: blocks_multiply_const_vxx_1
  id: blocks_multiply_const_vxx
  parameters:
    const: volume
    type: float
  states: {}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    cutoff_freq: 75e3
    decim: '1'
    gain: '1'
    samp_rate: samp_rate
    type: fir_filter_ccf
    width: 20e3
    win: window.WIN_HAMMING
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    autoscale: 'True'
    bw: samp_rate
    fc: tuner
    fftsize: '1024'
    gui_hint: 5,3,1,3
    name: Spectrum Analyzer Output of SDR
    type: complex
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    gui_hint: 5,0,1,3
    name: Oscilliscope Output of SDR
    size: '1024'
    srate: samp_rate
    type: complex
  states: {}
- name: qtgui_waterfall_sink_x_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate
    fc: tuner
    fftsize: '1024'
    gui_hint: 0,0,1,6
    name: 2 MHz Bandwidth Waterfall
    type: complex
  states: {}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    decim: '32'
    interp: '3'
    type: ccc
  states: {}
- name: rtlsdr_source_0
  id: rtlsdr_source
  parameters:
    bb_gain0: '20'
    bw0: 200e3
    freq0: tuner
    gain0: rf_gain
    gain_mode0: 'False'
    if_gain0: '20'
    sample_rate: samp_rate
    sync: sync
    type: fc32
  states: {}

connections:
- [analog_simple_squelch_cc_0, '0', analog_wfm_rcv_pll_0, '0']
- [analog_wfm_rcv_pll_0, '0', blocks_multiply_const_vxx_0, '0']
- [analog_wfm_rcv_pll_0, '1', blocks_multiply_const_vxx_1, '0']
- [blocks_multiply_const_vxx_0, '0', audio_sink_0, '0']
- [blocks_multiply_const_vxx_1, '0', audio_sink_0, '1']
- [low_pass_filter_0, '0', rational_resampler_xxx_0, '0']
- [rational_resampler_xxx_0, '0', analog_simple_squelch_cc_0, '0']
- [rtlsdr_source_0, '0', low_pass_filter_0, '0']
- [rtlsdr_source_0, '0', qtgui_freq_sink_x_0, '0']
- [rtlsdr_source_0, '0', qtgui_time_sink_x_0, '0']
- [rtlsdr_source_0, '0', qtgui_waterfall_sink_x_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
