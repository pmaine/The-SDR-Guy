options:
  parameters:
    author: pmain
    generate_options: qt_gui
    id: SArtlsdr
    output_language: python
    title: Simple Spectrum Analyzer
  states: {}

blocks:
- name: frequency
  id: variable_qtgui_range
  parameters:
    gui_hint: 0,0,1,3
    label: Frequency
    start: 500e3
    step: '10'
    stop: 1.766e9
    value: 850e3
    widget: eng_slider
  states: {}
- name: rf_gain
  id: variable_qtgui_range
  parameters:
    gui_hint: 1,0,1,3
    label: RF Gain (dB)
    start: '10'
    step: '1'
    stop: '100'
    value: '10'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 2e6
  states: {}
- name: display
  id: qtgui_tab_widget
  parameters:
    label0: Spectrum Analyzer (full spectrum)
    label1: Spectrum Zoom
    label2: Waterfall
    label3: Oscilloscope (time)
    num_tabs: '4'
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: frequency
    fftsize: '8192'
    gui_hint: display@0
    name: Spectrum Analyzer
    type: complex
  states: {}
- name: qtgui_freq_sink_x_1
  id: qtgui_freq_sink_x
  parameters:
    bw: 100e3
    fc: frequency
    fftsize: '4096'
    gui_hint: display@1
    name: Zoom Spectrum Analyzer (100 KHz )
    type: complex
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    gui_hint: display@3
    size: '1024'
    srate: samp_rate
    type: complex
  states: {}
- name: qtgui_waterfall_sink_x_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate
    fc: frequency
    fftsize: '1024'
    gui_hint: display@2
    type: complex
  states: {}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    decim: '20'
    fbw: '0.4'
    interp: '1'
    type: ccc
  states: {}
- name: rtlsdr_source_0
  id: rtlsdr_source
  parameters:
    bb_gain0: '20'
    bw0: samp_rate
    freq0: frequency
    gain0: rf_gain
    gain_mode0: 'False'
    if_gain0: '20'
    sample_rate: samp_rate
    sync: sync
    type: fc32
  states: {}

connections:
- [rational_resampler_xxx_0, '0', qtgui_freq_sink_x_1, '0']
- [rtlsdr_source_0, '0', qtgui_freq_sink_x_0, '0']
- [rtlsdr_source_0, '0', qtgui_time_sink_x_0, '0']
- [rtlsdr_source_0, '0', qtgui_waterfall_sink_x_0, '0']
- [rtlsdr_source_0, '0', rational_resampler_xxx_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
