options:
  parameters:
    author: JesterNoFool with The SDR Guys File
    generate_options: qt_gui
    id: rtlsdrHfTunerSsbDemod
    output_language: python
    title: Upper SSB Weaver Method
  states: {}

blocks:
- name: bandSelect
  id: variable_qtgui_chooser
  parameters:
    comment: 'GUI Hint: 0,0,1,20'
    gui_hint: 0,0,1,20
    label: Band Selection
    labels: '["80 m","40 m","20 m", "17 m", "15 m", "12 m", "10 m"]'
    num_opts: '0'
    options: '[3.5e6, 7e6, 14e6, 18.068e6, 21e6, 24.89e6, 28e6]'
    orient: Qt.QHBoxLayout
    type: real
    value: 14e6
    widget: radio_buttons
  states: {}
- name: freqSlider
  id: variable_qtgui_range
  parameters:
    comment: |-
      Start: 14.242-1.024
      Stop: 14.242+1.024
      Step: 0.001
      GUI Hint: 0,0,1,10
    gui_hint: 1,0,1,10
    label: Band Frequency (kHz)
    start: '-500'
    step: '0.1'
    stop: '500'
    value: '-500'
  states: {}
- name: ifGain
  id: variable_qtgui_range
  parameters:
    gui_hint: 2,10,1,10
    label: IF Gain (dB)
    start: '-60'
    step: '0.1'
    stop: '100'
    value: '0'
  states: {}
- name: myTaps
  id: variable
  parameters:
    comment: 'Value: firdes.complex_band_pass(1,samp_rate,((freqSlider*1e3)-25e3),((freqSlider*1e3)+25e3),10e3,5)'
    value: firdes.complex_band_pass(1,samp_rate/2,((freqSlider*1e3)-25e3),((freqSlider*1e3)+25e3),10e3,5)
  states: {}
- name: rfGain
  id: variable_qtgui_range
  parameters:
    gui_hint: 2,0,1,10
    label: RF Gain (dB)
    start: '0'
    step: '1'
    stop: '50'
    value: '10'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 2.4e6
  states: {}
- name: shift
  id: variable
  parameters:
    value: '1300'
  states: {}
- name: sideband
  id: variable_qtgui_chooser
  parameters:
    comment: 'GUI Hint: 0,10,1,10'
    gui_hint: 1,10,1,10
    label: Sideband
    label0: Lower Sideband
    label1: Upper Sideband
    num_opts: '2'
    option0: '-1'
    option1: '1'
    type: real
    value: '1'
  states: {}
- name: volume
  id: variable_qtgui_range
  parameters:
    comment: 'GUI Hint: 1,0,1,10'
    gui_hint: 3,0,1,10
    label: Volume (dB)
    start: '-100'
    step: '0.1'
    stop: '100'
    value: '-10'
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: 10e3+(shift*sideband)
    offset: '0'
    phase: '0'
    samp_rate: 50e3
    type: float
    waveform: analog.GR_COS_WAVE
  states: {}
- name: analog_sig_source_x_0_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: shift
    offset: '0'
    phase: '0'
    samp_rate: 25e3
    type: float
    waveform: analog.GR_COS_WAVE
  states: {}
- name: analog_sig_source_x_0_0_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: shift
    offset: '0'
    phase: '0'
    samp_rate: 25e3
    type: float
    waveform: analog.GR_SIN_WAVE
  states: {}
- name: analog_sig_source_x_0_1
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: 10e3+(shift*sideband)
    offset: '0'
    phase: '0'
    samp_rate: 50e3
    type: float
    waveform: analog.GR_SIN_WAVE
  states: {}
- name: audio_sink_0
  id: audio_sink
  parameters:
    samp_rate: '24000'
  states: {}
- name: blocks_add_xx_0
  id: blocks_add_xx
  parameters:
    type: float
  states: {}
- name: blocks_add_xx_1
  id: blocks_add_xx
  parameters:
    type: float
  states: {}
- name: blocks_complex_to_float_0
  id: blocks_complex_to_float
  parameters: {}
  states: {}
- name: blocks_delay_0
  id: blocks_delay
  parameters:
    comment: |-
      Ensures that filtered and
      non-filtered spectra are
      lined up in time.

      Delay: int(len(myTaps)/2)
    delay: int(len(myTaps)/2)
    type: complex
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: 10**(ifGain/20)
    type: complex
  states: {}
- name: blocks_multiply_const_vxx_0_0
  id: blocks_multiply_const_vxx
  parameters:
    const: sideband
    type: float
  states: {}
- name: blocks_multiply_xx_0
  id: blocks_multiply_xx
  parameters:
    type: float
  states: {}
- name: blocks_multiply_xx_0_0
  id: blocks_multiply_xx
  parameters:
    type: float
  states: {}
- name: blocks_multiply_xx_0_0_0
  id: blocks_multiply_xx
  parameters:
    type: float
  states: {}
- name: blocks_multiply_xx_0_0_1
  id: blocks_multiply_xx
  parameters:
    type: float
  states: {}
- name: blocks_rotator_cc_0
  id: blocks_rotator_cc
  parameters:
    comment: |-
      This provides the tuning through
      the spectrum.

      Phase Increment: 2*np.pi*(-freqSlider*1e3)/(samp_rate/2)
    phase_inc: 2*np.pi*(-freqSlider*1e3)/(samp_rate/2)
  states: {}
- name: blocks_rotator_cc_0_0
  id: blocks_rotator_cc
  parameters:
    comment: |-
      This creates the IF (intermediate frequency)
      in order to recreate an analog receiver.

      Phase Increment: 2*np.pi/5

      NOTE: The phase increment is equivalent
      to 2*np.pi*10e3/50e3, where the IF is
      set to 10 kHz.
    phase_inc: 2*np.pi/5
  states: {}
- name: fft_filter_xxx_0
  id: fft_filter_xxx
  parameters:
    comment: |-
      This is simply to show
      where in the full spectrum
      the zoom spectrum is located.
    decim: '1'
    taps: myTaps
    type: ccc
  states: {}
- name: filter_fft_low_pass_filter_0
  id: filter_fft_low_pass_filter
  parameters:
    comment: 'Gain: 10**(volume/20)'
    cutoff_freq: shift
    decim: '2'
    gain: 10**(volume/20)
    samp_rate: 50e3
    type: fff
    width: '300'
    win: window.WIN_HAMMING
  states: {}
- name: filter_fft_low_pass_filter_0_0
  id: filter_fft_low_pass_filter
  parameters:
    comment: 'Gain: 10**(volume/20)'
    cutoff_freq: shift
    decim: '2'
    gain: 10**(volume/20)
    samp_rate: 50e3
    type: fff
    width: '300'
    win: window.WIN_HAMMING
  states: {}
- name: freq_xlating_fft_filter_ccc_0
  id: freq_xlating_fft_filter_ccc
  parameters:
    center_freq: 600e3
    comment: 'Taps: firdes.low_pass(1,samp_rate,550e3,50e3,5)'
    decim: '2'
    samp_rate: samp_rate
    taps: firdes.low_pass(1,samp_rate,550e3,50e3,5)
  states: {}
- name: import_0
  id: import
  parameters:
    comment: |-
      Mainly use this to have a
      precise value of pi.

      Import: import numpy as np
    imports: import numpy as np
  states: {}
- name: myTabs
  id: qtgui_tab_widget
  parameters:
    gui_hint: 4,0,20,20
    label0: Spectra
    label1: Gain Adjust
    label2: Zoom Waterfall
    num_tabs: '3'
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate/2
    color1: '"black"'
    comment: |-
      Center Frequency: 14.242e6
      GUI Hint: 12,0,10,10
    fc: bandSelect+600e3
    fftsize: '8192'
    gui_hint: myTabs@0:14,0,10,10
    label1: Full Spectrum
    label2: Zoom Spectrum
    name: Full RF Spectrum
    nconnections: '2'
    type: complex
    ymax: '-20'
  states: {}
- name: qtgui_freq_sink_x_1
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate/48
    color1: '"black"'
    comment: |-
      Bandwidth: samp_rate/48
      GUI Hint: 3,0,10,20
    fc: '0'
    fftsize: '4096'
    grid: 'True'
    gui_hint: myTabs@0:4,0,10,20
    legend: 'False'
    name: Zoom Spectrum
    type: complex
    ymax: '-20'
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    color1: black
    comment: 'GUI Hint: 12,10,10,10'
    grid: 'True'
    gui_hint: myTabs@0:14,10,10,10
    legend: 'False'
    name: Audio Level
    size: '3200'
    srate: '32000'
    type: float
  states: {}
- name: qtgui_time_sink_x_1
  id: qtgui_time_sink_x
  parameters:
    gui_hint: myTabs@1:0,0,10,20
    legend: 'False'
    name: RTL-SDR Gain Adjust
    size: '24000'
    srate: samp_rate
    type: complex
  states: {}
- name: qtgui_waterfall_sink_x_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: 50e3
    fc: '0'
    fftsize: '4096'
    gui_hint: myTabs@2:0,0,20,20
    type: complex
  states: {}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    comment: |-
      Reduce the sample rate 
      for easier processing as
      well as for the zoom
      spectrum.
    decim: '24'
    interp: '1'
    type: ccc
  states: {}
- name: rational_resampler_xxx_1
  id: rational_resampler_xxx
  parameters:
    decim: '25'
    interp: '24'
    type: fff
  states: {}
- name: rtlsdr_source_0
  id: rtlsdr_source
  parameters:
    bb_gain0: '20'
    freq0: bandSelect
    gain0: rfGain
    gain_mode0: 'False'
    if_gain0: '20'
    sample_rate: samp_rate
    sync: sync
    type: fc32
  states: {}
- name: virtual_sink_0
  id: virtual_sink
  parameters:
    stream_id: zoomSpectrum
  states: {}
- name: virtual_sink_1
  id: virtual_sink
  parameters:
    stream_id: inphase
  states: {}
- name: virtual_sink_2
  id: virtual_sink
  parameters:
    stream_id: quadrature
  states: {}
- name: virtual_source_0
  id: virtual_source
  parameters:
    stream_id: zoomSpectrum
  states: {}
- name: virtual_source_1
  id: virtual_source
  parameters:
    stream_id: inphase
  states: {}
- name: virtual_source_2
  id: virtual_source
  parameters:
    stream_id: quadrature
  states: {}

connections:
- [analog_sig_source_x_0, '0', blocks_multiply_xx_0, '0']
- [analog_sig_source_x_0_0, '0', blocks_multiply_xx_0_0_1, '0']
- [analog_sig_source_x_0_0_0, '0', blocks_multiply_xx_0_0_0, '1']
- [analog_sig_source_x_0_1, '0', blocks_multiply_xx_0_0, '1']
- [blocks_add_xx_0, '0', blocks_multiply_xx_0, '1']
- [blocks_add_xx_0, '0', blocks_multiply_xx_0_0, '0']
- [blocks_add_xx_1, '0', qtgui_time_sink_x_0, '0']
- [blocks_add_xx_1, '0', rational_resampler_xxx_1, '0']
- [blocks_complex_to_float_0, '0', blocks_add_xx_0, '0']
- [blocks_complex_to_float_0, '1', blocks_add_xx_0, '1']
- [blocks_delay_0, '0', qtgui_freq_sink_x_0, '0']
- [blocks_multiply_const_vxx_0, '0', blocks_rotator_cc_0, '0']
- [blocks_multiply_const_vxx_0_0, '0', blocks_add_xx_1, '1']
- [blocks_multiply_xx_0, '0', virtual_sink_1, '0']
- [blocks_multiply_xx_0_0, '0', virtual_sink_2, '0']
- [blocks_multiply_xx_0_0_0, '0', blocks_multiply_const_vxx_0_0, '0']
- [blocks_multiply_xx_0_0_1, '0', blocks_add_xx_1, '0']
- [blocks_rotator_cc_0, '0', rational_resampler_xxx_0, '0']
- [blocks_rotator_cc_0_0, '0', blocks_complex_to_float_0, '0']
- [fft_filter_xxx_0, '0', qtgui_freq_sink_x_0, '1']
- [filter_fft_low_pass_filter_0, '0', blocks_multiply_xx_0_0_1, '1']
- [filter_fft_low_pass_filter_0_0, '0', blocks_multiply_xx_0_0_0, '0']
- [freq_xlating_fft_filter_ccc_0, '0', blocks_delay_0, '0']
- [freq_xlating_fft_filter_ccc_0, '0', blocks_multiply_const_vxx_0, '0']
- [freq_xlating_fft_filter_ccc_0, '0', fft_filter_xxx_0, '0']
- [rational_resampler_xxx_0, '0', qtgui_freq_sink_x_1, '0']
- [rational_resampler_xxx_0, '0', qtgui_waterfall_sink_x_0, '0']
- [rational_resampler_xxx_0, '0', virtual_sink_0, '0']
- [rational_resampler_xxx_1, '0', audio_sink_0, '0']
- [rtlsdr_source_0, '0', freq_xlating_fft_filter_ccc_0, '0']
- [rtlsdr_source_0, '0', qtgui_time_sink_x_1, '0']
- [virtual_source_0, '0', blocks_rotator_cc_0_0, '0']
- [virtual_source_1, '0', filter_fft_low_pass_filter_0, '0']
- [virtual_source_2, '0', filter_fft_low_pass_filter_0_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
