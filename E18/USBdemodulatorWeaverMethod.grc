options:
  parameters:
    author: JesterNoFool with The SDR Guys File
    generate_options: qt_gui
    id: SSBfromWebsiteUSBhamModdedV2
    output_language: python
    title: Upper SSB Weaver Method
  states: {}

blocks:
- name: center_frequency
  id: variable_qtgui_range
  parameters:
    comment: |-
      Start: 14.242-1.024
      Stop: 14.242+1.024
      Step: 0.001
      GUI Hint: 0,0,1,10
    gui_hint: 0,0,1,10
    label: Frequency (MHz)
    start: 14.242-1.024
    step: '0.001'
    stop: 14.242+1.024
    value: '14.273'
  states: {}
- name: freqOffset
  id: variable
  parameters:
    comment: |-
      This accounts for the SDR center
      frequency and sets up the offset
      for the sample file. This value is
      in MHz.

      Value: center_frequency-14.242
    value: center_frequency-14.242
  states: {}
- name: myTaps
  id: variable
  parameters:
    comment: 'Value: firdes.complex_band_pass(1,samp_rate,((freqOffset*1e6)-64e3),((freqOffset*1e6)+64e3),10e3,5)'
    value: firdes.complex_band_pass(1,samp_rate,((freqOffset*1e6)-64e3),((freqOffset*1e6)+64e3),10e3,5)
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 2.048e6
  states: {}
- name: shift
  id: variable
  parameters:
    value: '1300'
  states: {}
- name: sideband
  id: variable_qtgui_chooser
  parameters:
    comment: 'GUI Hint: 0,10,1,10'
    gui_hint: 0,10,1,10
    label: Sideband
    label0: Lower Sideband
    label1: Upper Sideband
    num_opts: '2'
    option0: '-1'
    option1: '1'
    type: real
    value: '1'
  states: {}
- name: volume
  id: variable_qtgui_range
  parameters:
    comment: 'GUI Hint: 1,0,1,10'
    gui_hint: 1,0,1,10
    label: Volume (dB)
    start: '-100'
    step: '0.1'
    stop: '100'
    value: '-10'
  states: {}
- name: analog_agc_xx_0
  id: analog_agc_xx
  parameters:
    comment: 'Reference: 0.5'
    gain: '1.0'
    max_gain: '65536'
    rate: '1e-4'
    reference: '0.5'
    type: complex
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: 16e3+(shift*sideband)
    offset: '0'
    phase: '0'
    samp_rate: 128e3
    type: float
    waveform: analog.GR_COS_WAVE
  states: {}
- name: analog_sig_source_x_0_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: shift
    offset: '0'
    phase: '0'
    samp_rate: 32e3
    type: float
    waveform: analog.GR_COS_WAVE
  states: {}
- name: analog_sig_source_x_0_0_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: shift
    offset: '0'
    phase: '0'
    samp_rate: 32e3
    type: float
    waveform: analog.GR_SIN_WAVE
  states: {}
- name: analog_sig_source_x_0_1
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: 16e3+(shift*sideband)
    offset: '0'
    phase: '0'
    samp_rate: 128e3
    type: float
    waveform: analog.GR_SIN_WAVE
  states: {}
- name: audio_sink_0
  id: audio_sink
  parameters:
    samp_rate: '32000'
  states: {}
- name: blocks_add_xx_1
  id: blocks_add_xx
  parameters:
    type: float
  states: {}
- name: blocks_complex_to_real_0
  id: blocks_complex_to_real
  parameters: {}
  states: {}
- name: blocks_delay_0
  id: blocks_delay
  parameters:
    comment: |-
      Ensures that filtered and
      non-filtered spectra are
      lined up in time.

      Delay: int(len(myTaps)/2)
    delay: int(len(myTaps)/2)
    type: complex
  states: {}
- name: blocks_float_to_complex_0
  id: blocks_float_to_complex
  parameters: {}
  states: {}
- name: blocks_multiply_const_vxx_0_0
  id: blocks_multiply_const_vxx
  parameters:
    const: sideband
    type: float
  states: {}
- name: blocks_multiply_xx_0
  id: blocks_multiply_xx
  parameters:
    type: float
  states: {}
- name: blocks_multiply_xx_0_0
  id: blocks_multiply_xx
  parameters:
    type: float
  states: {}
- name: blocks_multiply_xx_0_0_0
  id: blocks_multiply_xx
  parameters:
    type: float
  states: {}
- name: blocks_multiply_xx_0_0_1
  id: blocks_multiply_xx
  parameters:
    type: float
  states: {}
- name: blocks_rotator_cc_0
  id: blocks_rotator_cc
  parameters:
    comment: |-
      This provides the tuning through
      the spectrum.

      Phase Increment: -2*np.pi*freqOffset*1e6/samp_rate
    phase_inc: '-2*np.pi*freqOffset*1e6/samp_rate'
  states: {}
- name: blocks_rotator_cc_1
  id: blocks_rotator_cc
  parameters:
    phase_inc: 2*np.pi/8
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: blocks_wavfile_source_0
  id: blocks_wavfile_source
  parameters:
    file: C:\Users\pmain\Downloads\baseband_14242000Hz_19-46-33_19-07-2025-RTL-SDR-V3.wav
    nchan: '2'
    repeat: 'True'
  states: {}
- name: fft_filter_xxx_0
  id: fft_filter_xxx
  parameters:
    comment: |-
      This is simply to show
      where in the full spectrum
      the zoom spectrum is located.
    decim: '1'
    taps: myTaps
    type: ccc
  states: {}
- name: filter_fft_low_pass_filter_0
  id: filter_fft_low_pass_filter
  parameters:
    comment: 'Gain: 10**(volume/20)'
    cutoff_freq: shift
    decim: '4'
    gain: 10**(volume/20)
    samp_rate: 128e3
    type: fff
    width: '100'
    win: window.WIN_HAMMING
  states: {}
- name: filter_fft_low_pass_filter_0_0
  id: filter_fft_low_pass_filter
  parameters:
    comment: 'Gain: 10**(volume/20)'
    cutoff_freq: shift
    decim: '4'
    gain: 10**(volume/20)
    samp_rate: 128e3
    type: fff
    width: '100'
    win: window.WIN_HAMMING
  states: {}
- name: import_0
  id: import
  parameters:
    comment: |-
      Mainly use this to have a
      precise value of pi.

      Import: import numpy as np
    imports: import numpy as np
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    color1: '"black"'
    comment: |-
      Center Frequency: 14.242e6
      GUI Hint: 12,0,10,10
    fc: 14.242e6
    fftsize: '8192'
    gui_hint: 12,0,10,10
    label1: Full Spectrum
    label2: Zoom Spectrum
    name: Full RF Spectrum
    nconnections: '2'
    type: complex
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    color1: black
    comment: 'GUI Hint: 12,10,10,10'
    grid: 'True'
    gui_hint: 12,10,10,10
    legend: 'False'
    name: Audio Level
    size: '3200'
    srate: '32000'
    type: float
  states: {}
- name: qtgui_waterfall_sink_x_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate/16
    comment: |-
      Center Frequency: freqOffset*1e6
      Bandwidth: samp_rate/16
      GUI Hint: 2,0,10,20
    fc: center_frequency*1e6
    fftsize: '8192'
    gui_hint: 2,0,10,20
    int_min: '-85'
    name: Zoom Spectrum
    type: complex
    update_time: '0.01'
  states: {}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    comment: |-
      Reduce the sample rate 
      for easier processing as
      well as for the zoom
      spectrum.
    decim: '16'
    interp: '1'
    type: ccc
  states: {}
- name: virtual_sink_0
  id: virtual_sink
  parameters:
    stream_id: zoomSpectrum
  states: {}
- name: virtual_source_0
  id: virtual_source
  parameters:
    stream_id: zoomSpectrum
  states: {}

connections:
- [analog_agc_xx_0, '0', blocks_rotator_cc_1, '0']
- [analog_sig_source_x_0, '0', blocks_multiply_xx_0, '0']
- [analog_sig_source_x_0_0, '0', blocks_multiply_xx_0_0_1, '0']
- [analog_sig_source_x_0_0_0, '0', blocks_multiply_xx_0_0_0, '1']
- [analog_sig_source_x_0_1, '0', blocks_multiply_xx_0_0, '1']
- [blocks_add_xx_1, '0', audio_sink_0, '0']
- [blocks_add_xx_1, '0', qtgui_time_sink_x_0, '0']
- [blocks_complex_to_real_0, '0', blocks_multiply_xx_0, '1']
- [blocks_complex_to_real_0, '0', blocks_multiply_xx_0_0, '0']
- [blocks_delay_0, '0', qtgui_freq_sink_x_0, '0']
- [blocks_float_to_complex_0, '0', blocks_throttle_0, '0']
- [blocks_multiply_const_vxx_0_0, '0', blocks_add_xx_1, '1']
- [blocks_multiply_xx_0, '0', filter_fft_low_pass_filter_0, '0']
- [blocks_multiply_xx_0_0, '0', filter_fft_low_pass_filter_0_0, '0']
- [blocks_multiply_xx_0_0_0, '0', blocks_multiply_const_vxx_0_0, '0']
- [blocks_multiply_xx_0_0_1, '0', blocks_add_xx_1, '0']
- [blocks_rotator_cc_0, '0', rational_resampler_xxx_0, '0']
- [blocks_rotator_cc_1, '0', blocks_complex_to_real_0, '0']
- [blocks_throttle_0, '0', blocks_delay_0, '0']
- [blocks_throttle_0, '0', blocks_rotator_cc_0, '0']
- [blocks_throttle_0, '0', fft_filter_xxx_0, '0']
- [blocks_wavfile_source_0, '0', blocks_float_to_complex_0, '0']
- [blocks_wavfile_source_0, '1', blocks_float_to_complex_0, '1']
- [fft_filter_xxx_0, '0', qtgui_freq_sink_x_0, '1']
- [filter_fft_low_pass_filter_0, '0', blocks_multiply_xx_0_0_1, '1']
- [filter_fft_low_pass_filter_0_0, '0', blocks_multiply_xx_0_0_0, '0']
- [rational_resampler_xxx_0, '0', qtgui_waterfall_sink_x_0, '0']
- [rational_resampler_xxx_0, '0', virtual_sink_0, '0']
- [virtual_source_0, '0', analog_agc_xx_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
