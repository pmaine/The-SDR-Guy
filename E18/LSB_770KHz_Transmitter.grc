options:
  parameters:
    generate_options: qt_gui
    id: top_block
    output_language: python
    title: Lower Sideband Transmitter Example
  states: {}

blocks:
- name: aa
  id: variable_qtgui_range
  parameters:
    gui_hint: 0,0,1,4
    label: Fine Freq Adjust Hertz
    start: '-3000'
    step: '1'
    stop: '3000'
    value: '0'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '48000'
  states: {}
- name: analog_sig_source_x_2
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: aa
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {}
- name: audio_sink_0
  id: audio_sink
  parameters:
    samp_rate: samp_rate
  states: {}
- name: band_pass_filter_0
  id: band_pass_filter
  parameters:
    decim: '1'
    gain: '1'
    high_cutoff_freq: '4000'
    low_cutoff_freq: '300'
    samp_rate: samp_rate
    type: fir_filter_fff
    width: '300'
    win: window.WIN_HAMMING
  states: {}
- name: blocks_complex_to_real_0
  id: blocks_complex_to_real
  parameters: {}
  states: {}
- name: blocks_conjugate_cc_0
  id: blocks_conjugate_cc
  parameters: {}
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: '500e-3'
    type: float
  states: {}
- name: blocks_multiply_const_xx_0
  id: blocks_multiply_const_xx
  parameters:
    const: '2'
    type: complex
  states: {}
- name: blocks_multiply_xx_0
  id: blocks_multiply_xx
  parameters:
    type: complex
  states: {}
- name: blocks_wavfile_source_0
  id: blocks_wavfile_source
  parameters:
    file: C:\Users\pmain\Downloads\OldergnuRadioFiles\gnuRadioFiles-main\PaulAudio.wav
    repeat: 'True'
  states: {}
- name: hilbert_fc_1
  id: hilbert_fc
  parameters:
    num_taps: '240'
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    gui_hint: 1,0,1,4
    name: Lower Sideband Modulation
    type: complex
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    label1: Audio
    name: Audio
    size: '1024'
    srate: samp_rate
    type: float
  states: {}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    decim: '24'
    interp: '25'
    taps: ''
    type: ccc
  states: {}

connections:
- [analog_sig_source_x_2, '0', blocks_multiply_xx_0, '1']
- [band_pass_filter_0, '0', hilbert_fc_1, '0']
- [blocks_complex_to_real_0, '0', blocks_multiply_const_vxx_0, '0']
- [blocks_conjugate_cc_0, '0', blocks_multiply_xx_0, '0']
- [blocks_multiply_const_vxx_0, '0', audio_sink_0, '0']
- [blocks_multiply_const_vxx_0, '0', qtgui_time_sink_x_0, '0']
- [blocks_multiply_const_xx_0, '0', rational_resampler_xxx_0, '0']
- [blocks_multiply_xx_0, '0', blocks_multiply_const_xx_0, '0']
- [blocks_wavfile_source_0, '0', band_pass_filter_0, '0']
- [hilbert_fc_1, '0', blocks_conjugate_cc_0, '0']
- [rational_resampler_xxx_0, '0', blocks_complex_to_real_0, '0']
- [rational_resampler_xxx_0, '0', qtgui_freq_sink_x_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
