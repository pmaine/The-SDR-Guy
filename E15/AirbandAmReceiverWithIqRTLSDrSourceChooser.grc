options:
  parameters:
    author: Paul Maine
    generate_options: qt_gui
    id: AirbandAmReceiver
    output_language: python
    realtime_scheduling: '1'
    title: Airband AM Receiver
  states: {}

blocks:
- name: rf_gain
  id: variable_qtgui_range
  parameters:
    gui_hint: 3,0,1,3
    label: RF Gain
    start: '0'
    step: '1'
    stop: '70'
    value: '30'
  states: {}
- name: sample_rate
  id: variable
  parameters:
    value: 2.048e6
  states: {}
- name: tuner
  id: variable_qtgui_chooser
  parameters:
    gui_hint: 1,0,1,3
    label: Choose Frequency
    label0: TYS Knoxville Arrival/Departure 1
    label1: TYS Knoxville Arrival/Departure 2
    label2: TYS Knoxville Tower
    label3: TYS Knoxville ATIS ( Weather and More )
    label4: TYS Knoxville Ground
    num_opts: '5'
    option0: '118000000'
    option1: '123900000'
    option2: '121200000'
    option3: '128350000'
    option4: '121900000'
    orient: Qt.QHBoxLayout
    type: int
    value: '128350000'
    widget: radio_buttons
  states: {}
- name: volume
  id: variable_qtgui_range
  parameters:
    gui_hint: 2,0,1,3
    label: Volume
    start: '0'
    step: '50e-3'
    stop: '1'
    value: '300e-3'
  states: {}
- name: analog_agc_xx_0
  id: analog_agc_xx
  parameters:
    gain: '1.0'
    max_gain: '65536'
    rate: '625e-6'
    reference: '1.0'
    type: complex
  states: {}
- name: analog_am_demod_cf_0
  id: analog_am_demod_cf
  parameters:
    audio_decim: '4'
    audio_pass: '6000'
    audio_stop: '7500'
    chan_rate: 192e3
  states: {}
- name: analog_pll_carriertracking_cc_0
  id: analog_pll_carriertracking_cc
  parameters:
    max_freq: '3.272e-5'
    min_freq: '1.636e-5'
    w: '50e-3'
  states: {}
- name: audio_sink_0
  id: audio_sink
  parameters:
    samp_rate: '48000'
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: volume
    type: float
  states: {}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    cutoff_freq: 20e3
    decim: '1'
    gain: '1'
    samp_rate: sample_rate
    type: fir_filter_ccf
    width: 5e3
    win: window.WIN_HAMMING
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: sample_rate
    fc: tuner
    fftsize: '1024'
    gui_hint: 5,3,1,3
    name: Spectrum Analyzer
    type: complex
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    gui_hint: 5,0,1,3
    name: Oscilloscope
    size: '1024'
    srate: sample_rate
    type: complex
  states: {}
- name: qtgui_waterfall_sink_x_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: sample_rate
    fc: tuner
    fftsize: '1024'
    gui_hint: 0,0,1,6
    name: Waterfall
    type: complex
  states: {}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    decim: '32'
    interp: '3'
    type: ccc
  states: {}
- name: rtlsdr_source_0
  id: rtlsdr_source
  parameters:
    bb_gain0: '20'
    freq0: tuner
    gain0: rf_gain
    gain_mode0: 'False'
    if_gain0: '20'
    sample_rate: sample_rate
    sync: sync
    type: fc32
  states: {}

connections:
- [analog_agc_xx_0, '0', analog_pll_carriertracking_cc_0, '0']
- [analog_am_demod_cf_0, '0', blocks_multiply_const_vxx_0, '0']
- [analog_pll_carriertracking_cc_0, '0', analog_am_demod_cf_0, '0']
- [blocks_multiply_const_vxx_0, '0', audio_sink_0, '0']
- [low_pass_filter_0, '0', rational_resampler_xxx_0, '0']
- [rational_resampler_xxx_0, '0', analog_agc_xx_0, '0']
- [rtlsdr_source_0, '0', low_pass_filter_0, '0']
- [rtlsdr_source_0, '0', qtgui_freq_sink_x_0, '0']
- [rtlsdr_source_0, '0', qtgui_time_sink_x_0, '0']
- [rtlsdr_source_0, '0', qtgui_waterfall_sink_x_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
