options:
  parameters:
    author: Paul Maine
    generate_options: qt_gui
    id: MonoFmReceiver
    output_language: python
    realtime_scheduling: '1'
    title: 2 Meter Narrow Band FM Receiver
  states: {}

blocks:
- name: sample_rate
  id: variable
  parameters:
    value: '2048000'
  states: {}
- name: tuner
  id: variable_qtgui_range
  parameters:
    gui_hint: 1,0,1,3
    label: Tuner
    start: 144e6
    step: 5e3
    stop: 148e6
    value: 144.655e6
  states: {}
- name: blocks_complex_to_float_0
  id: blocks_complex_to_float
  parameters: {}
  states: {}
- name: blocks_wavfile_sink_0
  id: blocks_wavfile_sink
  parameters:
    bits_per_sample1: FORMAT_PCM_16
    file: C:\Users\pmain\SeventyCmIQ.wav
    format: FORMAT_WAV
    nchan: '2'
    samp_rate: sample_rate
  states: {}
- name: qtgui_sink_x_1
  id: qtgui_sink_x
  parameters:
    bw: sample_rate
    fc: tuner
    fftsize: '1024'
    showrf: 'True'
    type: complex
  states: {}
- name: rtlsdr_source_0
  id: rtlsdr_source
  parameters:
    bb_gain0: '20'
    bw0: 16e3
    freq0: tuner
    gain0: '50'
    gain_mode0: 'False'
    if_gain0: '20'
    sample_rate: sample_rate
    sync: sync
    type: fc32
  states: {}

connections:
- [blocks_complex_to_float_0, '0', blocks_wavfile_sink_0, '0']
- [blocks_complex_to_float_0, '1', blocks_wavfile_sink_0, '1']
- [rtlsdr_source_0, '0', blocks_complex_to_float_0, '0']
- [rtlsdr_source_0, '0', qtgui_sink_x_1, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
